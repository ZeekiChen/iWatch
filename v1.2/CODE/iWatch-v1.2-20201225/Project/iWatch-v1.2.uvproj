# Keil uVision project iWatch-v1.2.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: iWatch-v1.2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User\Bluetooth;..\User\Sensor;..\User\Rtc;..\User\Radio;..\User\System;..\User\PageManage;..\User;..\User\Display
  group Sensor
    ../User/Sensor/: BME280.c Ellipsoid fitting.c LSM6DSM.c LIS3MDL.c Sensor.c
  group Rtc
    ../User/Rtc/: PCF8563.c
  group Display
    ../User/Display/: Display.c oled.c
  group System
    ../User/System/: Buzzer.c Delay.c EEPROM.C IIC.c Sys.c Key.c
  group PageManage
    ../User/PageManage/: GUI_PAGE.c
  group Page
    ../User/Page/: page_menu.c page_bme280.c page_lsm6dsm.c page_watch.c page_snake.c page_flashlight.c page_pedometer.c page_compass.c page_mag_cal.c page_setting.c page_stopwatch.c page_cyberpunk.c page_settime.c
  group iWatch
    ../User/: main.c iWatch.c
