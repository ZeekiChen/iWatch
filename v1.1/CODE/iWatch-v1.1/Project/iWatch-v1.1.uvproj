# Keil uVision project iWatch-v1.1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: iWatch-v1.1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User\System;..\User\Sensor;..\User\Rtc;..\User\Radio;..\User\Oled;..\User\Bluetooth;..\User
  group Doc
    ../Doc/: README.txt
  group Bluebooth
    ../User/Bluetooth/: PW02.c
  group Sensor
    ../User/Sensor/: BME280.c Ellipsoid fitting.c HMC5883L.c LSM6DSM.c
  group Oled
    ../User/Oled/: oled.c
  group Rtc
    ../User/Rtc/: PCF8563.c
  group Radio
    ../User/Radio/: RDA5807M.c
  group System
    ../User/System/: Buzzer.c Delay.c Display.c EEPROM.C IIC.c PowerManage.c Sys.c
  group iWatch
    ../User/: main.c
